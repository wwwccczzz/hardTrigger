# Keil uVision project cameraHardTrigger.uvprojx, settings and files
target cameraHardTrigger (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: camera_hard_trigger +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: .\include;.\cmsis
  asm include: .\include;.\cmsis
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group 应用程序
    ./src/: main.c system_stm32f10x.c
  group 启动文件
    ./startup/: startup_stm32f10x_hd.s
